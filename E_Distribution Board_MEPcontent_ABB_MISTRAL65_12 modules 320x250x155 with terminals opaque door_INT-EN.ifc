Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-22T11:11:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 22 11:11:47 2021 * Host: SPOJAR-RO-LE * Database: C:\Users\spojar\AppData\Local\Temp\{45FE7B52-86B4-443C-BAB7-D106ECC8A1B7}\ifc * Database version: 5507 * Database creation date: Wed Sep 22 11:11:47 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Sep 22 11:11:47 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 22 11:11:47 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcElectricDistributionBoard: 12 modules 320x250x155 with terminals opaque door, E_Distribution Board_MEPcontent_ABB_MISTRAL65_4M-18M_INT-EN:12 modules 320x250x155 with terminals opaque door:78672
In: Level 1
Type - Material: Color RAL 7035
Type - Dimensions - Depth: 155 mm; Height: 250 mm; Width: 320 mm
Type - Electrical - Loads - Max Dissipation Power: 27 W; Maximum Current: 63 A
Type - Electrical Engineering - Nominal Voltage: 0 V
Type - Identity Data - Article Description: MISTRAL65 opaque door 12M 22SM; Article Type: 12 modules 320x250x155 with terminals opaque door; Base Family Version: 12.31; Cable Entry Finish: Smooth/Precut; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Cost: 0; Custom: no; Description: Consumer units MISTRAL65; EMCS Version: 4.0; ETIM Article Class: EC000214; Extractable Frame: No; Family Version: 12.31; GTIN: 8000126314317; GWT: 650°C; Halogen Free: Yes; Installation Temperature: - 25°C/+60°C; IP Rating: IP65; Knockout Resistance To Mechanical Impacts: IK08; Manufacturer: ABB; Manufacturer Art. No.: 1SLM006501A1102; Manufacturer URL: https://new.abb.com/low-voltage/products/system-pro-e/system-pro-e-comfort/mistral65; MEPcontent Class: DISTRIBUTION_BOARD; Model: 65; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels; Product Line: MISTRAL65; Protection Class: II; Resistance To Heat: BPT 70°C; Resistance To Mechanical Impacts: IK09; Revit Version: 2019; Type Name: 12 modules 320x250x155 with terminals opaque door; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Box: Color RAL 7035
Type - Other - Category: Electrical Equipment; Arc: no; Arc 1: no; Arc 2: yes; Arc 3: no; Bottom Height Blend: 250 mm; Bottom Width Blend: 320 mm; Caps: 85 mm; Caps Height: 30.9669 mm; Caps Visible: no; Control Type: 1; Depth Frame: 48 mm; Depth From Frame: 376 mm; Door Depth: 42 mm; Door Height: 63 mm; Door Height Handle: 82.5 mm; Door Height Locker: 125 mm; Door Inside Void: 40 mm; Door Limit Height: 16.4 mm; Door Medium Arc: 1741.8 mm; Door Position: 115 mm; Door Radius Arc: 788.7 mm; Door Radius Handle: 37.1 mm; Door Type Check: Opaque; Door Width: 311.7 mm; Family Name: E_Distribution Board_MEPcontent_ABB_MISTRAL65_4M-18M_INT-EN; First Type: no; Front Panel Distance: 155 mm; Height Inside Void: 62.2359 mm; Height Void: 150 mm; Height Void 2: 99.6936 mm; Hole Height: 75 mm; Hole Width: 20 mm; H Series: no; Insertion Point Offset: 0 mm; Inside Void: 40 mm; Second Type: yes; Second Type Transparent: no; Slot 1 Inside: 160 mm; Slot 2 Inside: 40 mm; Top Height Blend: 245.6 mm; Top Width Blend: 316 mm; Type Transparent: no; Wall Series: no; Without Terminals: no
Type - Visibility - Door Type: Opaque
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Offset: 0 mm
Dimensions - Area: 0.749411 m2; Volume: 0.0119227 m3
Electrical - Circuiting - Electrical Data: Power - Balanced 0 V/1-0 VA
Electrical - Loads - Apparent Load Phase A: 0 W; Apparent Load Phase B: 0 W; Apparent Load Phase C: 0 W; Power: 0 W; Total Connected: 0 W; Total Demand Factor: 1; Total Estimated Demand: 0 W
Identity Data - Mark: 1
Other - Door Angle: 0 deg; Door Type Check Condition: yes; Family: E_Distribution Board_MEPcontent_ABB_MISTRAL65_4M-18M_INT-EN: 12 modules 320x250x155 with terminals opaque door; Family and Type: E_Distribution Board_MEPcontent_ABB_MISTRAL65_4M-18M_INT-EN: 12 modules 320x250x155 with terminals opaque door; Left Clearance: 311.7 mm; Right Clearance: 0 mm; Second Type Visible: yes; Service Depth: 36.2 mm; Type: E_Distribution Board_MEPcontent_ABB_MISTRAL65_4M-18M_INT-EN: 12 modules 320x250x155 with terminals opaque door; Type Id: E_Distribution Board_MEPcontent_ABB_MISTRAL65_4M-18M_INT-EN: 12 modules 320x250x155 with terminals opaque door; Type Visible: no
Phasing - Phase Created: New Construction
Visibility - Reverse Door Mounting: no; Show Service Area: no
