Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-22T11:11:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 22 11:11:22 2021 * Host: SPOJAR-RO-LE * Database: C:\Users\spojar\AppData\Local\Temp\{73EBE883-658F-4CA9-A0F7-2612B6192E06}\ifc * Database version: 5507 * Database creation date: Wed Sep 22 11:11:21 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Sep 22 11:11:22 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 22 11:11:22 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcElectricDistributionBoard: 4 modules 152x202x117 H without terminals opaque door, E_Distribution Board_MEPcontent_ABB_MISTRAL65_4M-18M_INT-EN:4 modules 152x202x117 H without terminals opaque door:78643
In: Level 1
Type - Material: Color RAL 7035
Type - Dimensions - Depth: 117 mm; Height: 202 mm; Width: 152 mm
Type - Electrical - Loads - Max Dissipation Power: 12 W; Maximum Current: 63 A
Type - Electrical Engineering - Nominal Voltage: 0 V
Type - Identity Data - Article Description: MISTRAL65H opaque door 4M; Article Type: 4 modules 152x202x117 H without terminals opaque door; Base Family Version: 12.31; Cable Entry Finish: Smooth/Precut; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Cost: 0; Custom: no; Description: Consumer units MISTRAL65; EMCS Version: 4.0; ETIM Article Class: EC000214; Extractable Frame: No; Family Version: 12.31; GTIN: 8000126299281; GWT: 750°C; Halogen Free: NO; Installation Temperature: - 25°C/+60°C; IP Rating: IP65; Knockout Resistance To Mechanical Impacts: IK08; Manufacturer: ABB; Manufacturer Art. No.: 1SLM006500A2110; Manufacturer URL: https://new.abb.com/low-voltage/products/system-pro-e/system-pro-e-comfort/mistral65; MEPcontent Class: DISTRIBUTION_BOARD; Model: 65; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels; Product Line: MISTRAL65; Protection Class: II; Resistance To Heat: BPT 70°C; Resistance To Mechanical Impacts: IK10; Revit Version: 2019; Type Name: 4 modules 152x202x117 H without terminals opaque door; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Box: Color RAL 7035
Type - Other - Category: Electrical Equipment; Arc: yes; Arc 1: no; Arc 2: no; Arc 3: no; Bottom Height Blend: 200 mm; Bottom Width Blend: 150 mm; Caps: 0 mm; Caps Height: 30.9669 mm; Caps Visible: no; Control Type: 0; Depth Frame: 42 mm; Depth From Frame: 202 mm; Door Depth: 42 mm; Door Height: 40 mm; Door Height Handle: 59 mm; Door Height Locker: 101.06 mm; Door Inside Void: 29.8 mm; Door Limit Height: 7.8 mm; Door Medium Arc: 374.2 mm; Door Position: 87.2 mm; Door Radius Arc: 374.2 mm; Door Radius Handle: 37.1 mm; Door Type Check: Opaque; Door Width: 143.7 mm; Family Name: E_Distribution Board_MEPcontent_ABB_MISTRAL65_4M-18M_INT-EN; First Type: yes; Front Panel Distance: 117 mm; Height Inside Void: 62.2359 mm; Height Void: 150 mm; Height Void 2: 99.6936 mm; Hole Height: 150 mm; Hole Width: 18.4467 mm; H Series: no; Insertion Point Offset: 0 mm; Inside Void: 29.8 mm; Second Type: no; Second Type Transparent: no; Slot 1 Inside: 64.0981 mm; Slot 2 Inside: 160 mm; Top Height Blend: 197.6 mm; Top Width Blend: 147 mm; Type Transparent: no; Wall Series: no; Without Terminals: yes
Type - Visibility - Door Type: Opaque
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Offset: 0 mm
Dimensions - Area: 0.257768 m2; Volume: 0.0033743 m3
Electrical - Circuiting - Electrical Data: Power - Balanced 0 V/1-0 VA
Electrical - Loads - Apparent Load Phase A: 0 W; Apparent Load Phase B: 0 W; Apparent Load Phase C: 0 W; Power: 0 W; Total Connected: 0 W; Total Demand Factor: 1; Total Estimated Demand: 0 W
Identity Data - Mark: 1
Other - Door Angle: 0 deg; Door Type Check Condition: yes; Family: E_Distribution Board_MEPcontent_ABB_MISTRAL65_4M-18M_INT-EN: 4 modules 152x202x117 H without terminals opaque door; Family and Type: E_Distribution Board_MEPcontent_ABB_MISTRAL65_4M-18M_INT-EN: 4 modules 152x202x117 H without terminals opaque door; Left Clearance: 143.7 mm; Right Clearance: 0 mm; Second Type Visible: no; Service Depth: 30 mm; Type: E_Distribution Board_MEPcontent_ABB_MISTRAL65_4M-18M_INT-EN: 4 modules 152x202x117 H without terminals opaque door; Type Id: E_Distribution Board_MEPcontent_ABB_MISTRAL65_4M-18M_INT-EN: 4 modules 152x202x117 H without terminals opaque door; Type Visible: yes
Phasing - Phase Created: New Construction
Visibility - Reverse Door Mounting: no; Show Service Area: no
