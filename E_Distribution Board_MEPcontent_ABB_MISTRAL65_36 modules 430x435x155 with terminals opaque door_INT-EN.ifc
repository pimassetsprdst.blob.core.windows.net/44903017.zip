Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-22T11:10:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 22 11:10:03 2021 * Host: SPOJAR-RO-LE * Database: C:\Users\spojar\AppData\Local\Temp\{F818140E-6E3D-4923-BF3E-EAAB6667BD42}\ifc * Database version: 5507 * Database creation date: Wed Sep 22 11:10:02 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Sep 22 11:10:02 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 22 11:10:02 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcElectricDistributionBoard: 36 modules 430x435x155 with terminals opaque door, E_Distribution Board_MEPcontent_ABB_MISTRAL65_24M-36M_INT-EN:36 modules 430x435x155 with terminals opaque door:66902
In: Level 1
Type - Material: Color RAL 7035
Type - Dimensions - Depth: 155 mm; Height: 435 mm; Width: 430 mm
Type - Electrical - Loads - Max Dissipation Power: 43 W; Maximum Current: 125 A
Type - Electrical Engineering - Nominal Voltage: 0 V
Type - Identity Data - Article Description: MISTRAL65 opaque door 36M 2 ROWS 52SM; Article Type: 36 modules 430x435x155 with terminals opaque door; Base Family Version: 12.31; Cable Entry Finish: Smooth/Precut; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Cost: 0; Custom: no; Description: Consumer units MISTRAL65; EMCS Version: 4.0; ETIM Article Class: EC000214; Extractable Frame: Yes; Family Version: 12.31; GTIN: 8000126314289; GWT: 650°C; Halogen Free: Yes; Installation Temperature: - 25°C/+60°C; IP Rating: IP65; Knockout Resistance To Mechanical Impacts: IK08; Manufacturer: ABB; Manufacturer Art. No.: 1SLM006501A1105; Manufacturer URL: https://new.abb.com/low-voltage/products/system-pro-e/system-pro-e-comfort/mistral65; MEPcontent Class: DISTRIBUTION_BOARD; Model: 65; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels; Product Line: MISTRAL65; Protection Class: II; Resistance To Heat: BPT 70°C; Resistance To Mechanical Impacts: IK09; Revit Version: 2019; Type Name: 36 modules 430x435x155 with terminals opaque door; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Box: Color RAL 7035
Type - Other - Category: Electrical Equipment; Arc 2: no; Arc 3: yes; Bottom Height Blend: 435 mm; Bottom Width Blend: 430 mm; Caps: 139 mm; Caps Height: 62 mm; Caps Visible: yes; Depth Frame: 49 mm; Door Depth: 42 mm; Door Height: 71 mm; Door Height Handle: 177 mm; Door Height Locker: 217.7 mm; Door Inside Void: 40 mm; Door Limit Height: 16.4 mm; Door Medium Arc: 3178.9 mm; Door Radius Arc: 1434.8 mm; Door Radius Handle: 37.1 mm; Door Type Check: Opaque; Door Width: 421.8 mm; Family Name: E_Distribution Board_MEPcontent_ABB_MISTRAL65_24M-36M_INT-EN; First Type: no; Height Inside Void: 62.2359 mm; Height Void: 250 mm; Height Void 2: 99.6936 mm; Hole Height: 88.5 mm; Hole Width: 20 mm; Inside Void: 40 mm; Second Type: yes; Second Type Transparent: no; Slot 1 Inside: 160 mm; Slot 2 Inside: 40 mm; Top Height Blend: 433.3 mm; Top Width Blend: 428.3 mm; Type Transparent: no
Type - Visibility - Door Type: Opaque
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Offset: 0 mm
Dimensions - Area: 1.59021 m2; Volume: 0.0281063 m3
Electrical - Circuiting - Electrical Data: Power - Balanced 0 V/1-0 VA
Electrical - Loads - Apparent Load Phase A: 0 W; Apparent Load Phase B: 0 W; Apparent Load Phase C: 0 W; Power: 0 W; Total Connected: 0 W; Total Demand Factor: 1; Total Estimated Demand: 0 W
Identity Data - Mark: 1
Other - Door Angle: 0 deg; Door Type Check Condition: yes; Family: E_Distribution Board_MEPcontent_ABB_MISTRAL65_24M-36M_INT-EN: 36 modules 430x435x155 with terminals opaque door; Family and Type: E_Distribution Board_MEPcontent_ABB_MISTRAL65_24M-36M_INT-EN: 36 modules 430x435x155 with terminals opaque door; Left Clearance: 421.8 mm; Right Clearance: 0 mm; Second Type Visible: yes; Type: E_Distribution Board_MEPcontent_ABB_MISTRAL65_24M-36M_INT-EN: 36 modules 430x435x155 with terminals opaque door; Type Id: E_Distribution Board_MEPcontent_ABB_MISTRAL65_24M-36M_INT-EN: 36 modules 430x435x155 with terminals opaque door; Type Visible: no
Phasing - Phase Created: New Construction
Visibility - Reverse Door Mounting: no; Show Service Area: no
